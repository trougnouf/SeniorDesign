# Keil uVision project Project.uvprojx, settings and files
target STM32746G_Nucleo (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.2.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32746G_Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32F7XX_NUCLEO_144ADAFRUIT_TFT_JOY_SD_ID802
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/src/include/ipv4;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Utilities;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32F7xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c ip_addr.c igmp.c inet_chksum.c inet.c ip_frag.c ip.c autoip.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c tasks.c croutine.c timers.c list.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netbuf.c api_msg.c netdb.c api_lib.c tcpip.c sockets.c err.c netifapi.c
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Application/User
    ../Src/: main.c app_ethernet.c httpserver-netconn.c ethernetif.c fs.c stm32f7xx_it.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: pbuf.c dns.c sys.c udp.c memp.c def.c init.c mem.c tcp_out.c tcp_in.c tcp.c stats.c dhcp.c netif.c raw.c lwip_timers.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_eth.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma.c stm32f7xx_hal_spi.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cortex.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
software components: CMSIS:CORE 4.1.0
