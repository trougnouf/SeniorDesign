# IAR project SW9000.ewp, settings and files
configuration SW9000 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RE ST STM32L476RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: SW9000.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l476xx.s startup_stm32l476xx.s
  group Application/User
    ../Src/: bsp_driver_sd.c fatfs.c freertos.c main.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c stm32l4xx_it.c freertos.c fatfs.c main.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_TIM.c stm32l4xx_it.c bsp_driver_sd.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sai.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma.c stm32l4xx_hal_spi.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c event_groups.c list.c croutine.c timers.c tasks.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portasm.s port.c
